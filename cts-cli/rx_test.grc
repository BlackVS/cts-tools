options:
  parameters:
    author: CTS
    category: '[RX to FIFO]'
    generate_options: qt_gui
    id: rx_test
    output_language: python
    run_options: run
    title: rx_test
  states: {}

blocks:
- name: config_file
  id: variable
  parameters:
    value: config_file_path
  states: {}
- name: fifo
  id: variable
  parameters:
    value: os.path.join(os.path.expanduser('~'), "cts.fifo")
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: config_file_path
  id: parameter
  parameters:
    label: Configuration file path
    value: '"./config.cfg"'
  states: {}
- name: epy_mkfifo
  id: epy_module
  parameters:
    source_code: |-
      import os

      path = os.path.join(os.path.expanduser('~'), "cts.fifo")

      if not os.path.exists(path):
          try:
              os.mkfifo(path)
          except OSError as e:
              print("Cannot create FIFO '{}': {}".format(path, e))
          else:
              print("Created FIFO: {}".format(path))
              print("IMPORTANT: Before you can see the source sample rate, you must start consuming samples from the FIFO")
      else:
          print("FIFO already exists (not creating): {}".format(path))
          print("IMPORTANT: Before you can see the source sample rate, you must start consuming samples from the FIFO")
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: rf_over_ip_source_1
  id: rf_over_ip_source
  parameters:
    parent: self if 'self' in locals() else None
    rx_frequency: rx_frequency
    samp_rate: samp_rate
    server_address_format: '"tcp://%s:%d"'
    server_bw_per_port: '1000000'
    server_ip: server_ip
    server_port_base: '10000'
    throttle: '1'
    zmq_rx_timeout: '1000'
  states: {}
- name: rx_frequency
  id: parameter
  parameters:
    label: RX Frequency
    type: intx
    value: '471000000'
  states: {}
- name: server_ip
  id: parameter
  parameters:
    label: Server IP
    type: str
    value: '"34.215.122.191"'
  states: {}

connections:
- [rf_over_ip_source_1, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
