options:
  parameters:
    author: VVS
    category: '[RX to FIFO]'
    generate_options: qt_gui
    id: rx_to_file
    output_language: python
    run_options: run
    title: RX to FILE
  states: {}

blocks:
- name: config_file
  id: variable
  parameters:
    value: config_file_path
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: server_address
  id: variable
  parameters:
    value: server_address_format % (server_ip, server_port) if server_address_format != "" else ""
  states: {}
- name: server_address_format
  id: variable_config
  parameters:
    config_file: config_file
    option: '"server_address_format"'
    section: '"main"'
    type: string
    value: '"tcp://%s:%d"'
    writeback: None
  states: {}
- name: server_bw_per_port
  id: variable_config
  parameters:
    config_file: config_file
    option: '"server_bw_per_port"'
    section: main
    type: int
    value: '1000000'
    writeback: None
  states: {}
- name: server_port
  id: variable
  parameters:
    value: int(server_port_base + (rx_frequency / server_bw_per_port))
  states: {}
- name: server_port_base
  id: variable_config
  parameters:
    config_file: config_file
    option: '"server_port_base"'
    section: main
    type: int
    value: '10000'
    writeback: None
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: os.path.join(os.path.expanduser('~'), "cts.raw")
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: config_file_path
  id: parameter
  parameters:
    label: Configuration file path
    value: '"./config.cfg"'
  states: {}
- name: epy_mkfifo
  id: epy_module
  parameters:
    source_code: |-
      import os

      path = os.path.join(os.path.expanduser('~'), "cts.fifo")

      if not os.path.exists(path):
          try:
              os.mkfifo(path)
          except OSError as e:
              print("Cannot create FIFO '{}': {}".format(path, e))
          else:
              print("Created FIFO: {}".format(path))
              print("IMPORTANT: Before you can see the source sample rate, you must start consuming samples from the FIFO")
      else:
          print("FIFO already exists (not creating): {}".format(path))
          print("IMPORTANT: Before you can see the source sample rate, you must start consuming samples from the FIFO")
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rf_over_ip_source_0
  id: rf_over_ip_source
  parameters:
    parent: self if 'self' in locals() else None
    rx_frequency: rx_frequency
    samp_rate: samp_rate
    server_address_format: server_address_format
    server_bw_per_port: server_bw_per_port
    server_ip: server_ip
    server_port_base: server_port_base
    throttle: throttle
    zmq_rx_timeout: zmq_rx_timeout
  states: {}
- name: rx_frequency
  id: parameter
  parameters:
    label: RX Frequency
    type: intx
    value: '900000000'
  states: {}
- name: server_ip
  id: parameter
  parameters:
    label: Server IP
    type: str
    value: '"127.0.0.1"'
  states: {}
- name: throttle
  id: parameter
  parameters:
    label: Throttle
    type: intx
    value: '1'
  states: {}
- name: zmq_rx_timeout
  id: parameter
  parameters:
    label: ZMQ RX Timeout
    type: intx
    value: '1000'
  states: {}

connections:
- [rf_over_ip_source_0, '0', blocks_file_sink_0, '0']
- [rf_over_ip_source_0, '0', blocks_tag_debug_0, '0']
- [rf_over_ip_source_0, '0', qtgui_sink_x_0, '0']
- [rf_over_ip_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
